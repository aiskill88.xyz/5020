Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-10-19T11:51:41
Written by: IfcOpenShell v0.7.0-dc67287d
Made in: IfcOpenShell v0.7.0-dc67287d

# IfcWall: DEMO2, WALL 2
In: Ground Floor
Type - Pset_WallCommon - FireRating: -/-/-

# IfcWall: DEMO3, WALL 3
In: Ground Floor
Type - Pset_WallCommon - FireRating: 120/120/120

# IfcWall: DEMO4, WALL 4
In: Ground Floor
Type - Pset_WallCommon - FireRating: FOOBAR
